SECTIONS {
    . = 0x10000; /* 设置起始地址 */
    .text : { *(.text) } /* 代码段 */
    . = 0x20000; /* 数据段起始地址 */
    .data : { *(.data) } /* 数据段 */
    .bss : { *(.bss) } /* 未初始化数据段 */
}